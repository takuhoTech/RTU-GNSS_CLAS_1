# Repository takuhoTech/RTU-GNSS_CLAS_1

File README.md:

# RTU-GNSS CLAS 1
Ready-to-use GNSS+CLAS receiver with integrated loop antenna

## KiCad design Hardware/CLAS_Combo_Breakout_MovingBase-HAT/CLAS_Combo_Breakout_MovingBase-HAT.kicad_pcb

Parts:
C1, C2, C3, C5, C6, C8, C13: 0.1u; C_0603_1608Metric
C4: 1u; C_0603_1608Metric
C7, C9: 47μF6.3V X5R 1608; C_0603_1608Metric
C10: 100μF10V X5R 3216; C_1206_3216Metric
C11: 2200pF50V CH 1608; C_0603_1608Metric
C12: 220μF4V X6S 3216; C_1206_3216Metric
D1, D7: CUHS20S30
D2: RED; LED_0603_1608Metric
D3: GREEN; LED_0603_1608Metric
D4: RTK; LED_0603_1608Metric
D5: GEO; LED_0603_1608Metric
D6: PPS; LED_0603_1608Metric
H1, H2, H3: MH; MountingHole_2.2mm_M2_Pad_Via
J1: MMCX; MMCX_Samtec_MMCX-P-P-H-ST-SM1_Male
J2: SMA; SMA_Molex_0732512440_embed
J3: SWD; PinHeader_2x05_P1.27mm_Vertical
J4: ZED; PinHeader_1x11_P2.54mm_Vertical
J5: BATT; JST_PH_S2B-PH-K_1x02_P2.00mm_Horizontal
J6: NEO; PinHeader_1x07_P2.54mm_Vertical
J7: USB_C_Receptacle_USB2.0; USB_C_Receptacle_5077CR-16-SMC2-BK-TR
J8: RS485; JST_PH_S3B-PH-K_1x03_P2.00mm_Horizontal
Q1: AO3415A; SOT-23
R1, R2: 33; R_0603_1608Metric
R3, R18, R20, R21, R22, R23: 10k; R_0603_1608Metric
R4: RILIM; R_0603_1608Metric
R5, R6, R7, R8, R9: 1k; R_0603_1608Metric
R10: 1M; R_0603_1608Metric
R11: 510k; R_0603_1608Metric
R12: 100k; R_0603_1608Metric
R13: 10; R_0603_1608Metric
R14: Rtop; R_0603_1608Metric
R15: Rbtm; R_0603_1608Metric
R16, R17: 5.1k; R_0603_1608Metric
R19: 26.2k; R_0603_1608Metric
R24: 120; R_0603_1608Metric
SW1: SW_Push; SW_Push_1P1T_NO_Vertical_Wuerth_434133025816
SW2: SW_SPDT; SW_SPDT_SSSS213202
U1: CH340K; SSOP-10_3.9x4.9mm_P1.00mm
U2: TMUX131; Texas_RMG0012A_1.8x1.8mm_P0.4mm
U3: ISP4520-AS; ISP4520-AS_with_Keep-Out
U4: MCP73831-2-OT; SOT-23-5
U5: LTM4693; Converter_DCDC_AnalogDevices_LTM4693
U6: USBLC6-2P6; SOT-666
U7: MAX3485; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
+3.3V: C1.1, C2.1, C3.2, C4.1, C5.1, C12.1, C13.2, D1.1 (K), J3.1 (VTref), J4.9, J6.7, R3.1, R7.1, R22.1, R23.1, U1.7 (VCC), U1.10 (V3), U2.12 (VDD), U3.15 (VDD), U5.C5 (VOUT), U5.D4 (VOUT), U5.D5 (VOUT), U7.8 (VCC)
+BATT: C9.1, J5.2, Q1.3 (D), R10.1, U4.3 (VBAT)
/BaseMode: R21.1, U2.2 (SEL1), U3.9 (P0_13), U7.2 (~RE), U7.3 (DE)
/CH340K_RXD: U1.9 (RXD), U2.3 (S1B)
/CH340K_TXD: R2.2, U2.4 (S2B)
/D+: J7.A6 (D+), J7.B6 (D+), U1.1 (UD+), U6.1 (I/O1), U6.6 (I/O1)
/D-: J7.A7 (D-), J7.B7 (D-), U1.2 (UD-), U6.3 (I/O2), U6.4 (I/O2)
/DTR: C6.1, U1.4 (~DTR)
/EXTANT_DETECT: J6.1, U3.6 (P0_22)
/EXTINT_NEO: J6.5, U3.3 (P0_10/NFC2)
/EXTINT_ZED: J4.4, U3.18 (P0_30_AIN6)
/GEO: J4.1, R8.1, U3.11 (P0_05_AIN3)
/RESET: C6.2, D1.2 (A), J3.10 (~RESET), R3.2, SW1.1, U3.40 (P0_21/RESET)
/RESET_ZED_NEO: J6.2, U3.4 (P0_17)
/RS485_A: J8.3, R24.2, U7.6 (A)
/RS485_B: J8.2, R24.1, U7.7 (B)
/RS485_RXD: R23.2, U2.7 (S1A), U7.4 (DI)
/RS485_TXD: R22.2, U2.6 (S2C), U7.1 (RO)
/RTK: D4.1 (K), J4.2, U3.16 (P0_02_AIN0)
/RXD1_NEO: J6.3
/RXD1_ZED: J4.6, U2.5 (S1C)
/RoverMode: R20.1, U2.1 (SEL0), U3.7 (P0_09/NFC1)
/SCL: J4.11, U3.5 (P0_07)
/SDA: J4.10, U3.2 (P0_12)
/SWDCLK: J3.4 (SWDCLK/TCK), U3.37 (SWDCLK)
/SWDIO: J3.2 (SWDIO/TMS), U3.38 (SWDIO)
/SWO: J3.6 (SWO/TDO), U3.41 (P0_18/TRCDAT0)
/TP: J4.3, R9.1, U3.17 (P0_31_AIN7)
/TXD1_NEO: J6.4
/TXD1_ZED: J4.7, U2.8 (S2A)
/TX_RDY: J4.5, U3.20 (P0_28_AIN4)
/VBAT: R10.2, R11.1, U3.13 (P0_03_AIN1)
/nRF52_RXD: U2.10 (D2), U3.8 (P0_08)
/nRF52_TXD: R1.1, U2.11 (D1)
/~CHG_STAT: R5.2, R6.1, U3.19 (P0_29_AIN5), U4.1 (STAT)
/~VBAT_EN: R11.2, U3.12 (P0_04_AIN2)
GND: C1.2, C2.2, C3.1, C4.2, C5.2, C7.1, C8.1, C9.2, C10.2, C11.2, C12.2, C13.1, D3.1 (K), D5.1 (K), D6.1 (K), H1.1, H2.1, H3.1, J1.2 (Ext), J2.2 (Ext), J3.3 (GND), J3.5 (GND), J3.9 (GNDDetect), J4.8, J5.1, J6.6, J7.A1 (GND), J7.A12 (GND), J7.B1 (GND), J7.B12 (GND), J7.S1 (SHIELD), J8.1, R4.1, R12.1, R15.2, R16.2, R17.2, R19.2, R20.2, R21.2, SW1.2, SW2.3 (C), U1.3 (GND), U1.11 (EP), U2.9 (GND), U3.1 (GND), U3.14 (GND), U3.21 (GND), U3.22 (GND), U3.23 (GND), U3.26 (GND), U3.27 (GND), U3.28 (GND), U3.29 (GND), U3.30 (GND), U3.31 (GND), U3.32 (GND), U3.33 (GND), U3.36 (GND), U3.74 (GND), U4.2 (VSS), U5.A1 (GND), U5.A3 (GND), U5.A5 (GND), U5.B1 (GND), U5.B3 (GND), U5.B5 (GND), U5.C3 (GND), U6.2 (GND), U7.5 (GND)
unnamed: C11.1, R18.2
unnamed: D2.1 (K), R5.1
unnamed: D3.2 (A), R6.2
unnamed: D4.2 (A), R7.2
unnamed: D5.2 (A), R8.2
unnamed: D6.2 (A), R9.2
unnamed: J1.1 (In), J2.1 (In)
unnamed: J7.A5 (CC1), R16.1
unnamed: J7.B5 (CC2), R17.1
unnamed: Q1.1 (G), R12.2, R13.2
unnamed: R1.2, U3.10 (P0_06)
unnamed: R2.1, U1.8 (TXD)
unnamed: R4.2, U4.5 (PROG)
unnamed: R14.2, SW2.1 (A)
unnamed: R15.1, SW2.2 (B), U5.E1 (RUN/UVLO)
unnamed: R18.1, U5.E5 (COMP)
unnamed: R19.1, U5.E4 (FB)
unnamed: U3.24 (LORA_TR), U3.25 (LORA_ANT)
unnamed: U3.34 (BLE_ANT), U3.35 (BLE_TR)
unnamed: U5.A2 (SW1), U5.B2 (SW1), U5.C2 (SW1)
unnamed: U5.A4 (SW2), U5.B4 (SW2), U5.C4 (SW2)
VBUS: C7.2, C8.2, D2.2 (A), D7.2 (A), J7.A4 (VBUS), J7.A9 (VBUS), J7.B4 (VBUS), J7.B9 (VBUS), R13.1, U4.4 (VDD), U6.5 (VBUS)
VDD: C10.1, D7.1 (K), Q1.2 (S), R14.1, U5.C1 (VIN), U5.D1 (VIN), U5.D2 (VIN), U5.D3 (SS), U5.E2 (MODE/SYNC)

Notes on the sheet:
USB
Base Mode
GNSSの各種ピンも繋げる
USB Mode
スイッチOFF時にUVLOを設定する抵抗に電流が流れない
33uF @5V
9.4uF @5V
Interface
RTK_STAT
| SEL0 ----- | Low | High | Low | High
充電中は赤色LEDが点灯 充電が完了すると緑色LEDが点灯 シャットダウンまたはバッテリ未接続で両方点灯 そのときCHG_STATは2.5Vになるはず
| RS485 ------- | Receive | Receive | Transmit | Transmit
BaseMode ------ Low Low High High
UART Mode
USB2Serial
AUTO RESET
S1A
Rover Mode
Debug
SDA,SCLは下ボードでプルアップ
ILIM=1000/RILIM [A]
TIMEPULSE
42uF @4.2V
TXはダンピング抵抗内臓
SEL1
AとCを逆にする場合は SELに繋がるBaseModeとRoverModeを逆にする BaseModeがHighのときに送信するのは変わらないので REとDEはそのまま
88uF @3.3V
| ------- | B | C | A | Disable
CPU
UARTは正論理だが信号が無いときは3.3Vなのでプルアップ
3.300V @26.26k
Adafruit Featherで指定されているI2CピンはSX1261とのSPIで使われているため variant.hを編集して、ISP4520のデータシートの設計例で指定されている SCL:P0_07 SDA:P0_12 に変更
CHG_STATはアナログピンに接続しユニバーサル領域にも引き出す
SEL1 ---- Low Low High High
| RoverMode -------- | Low | High | Low | High
SDA,SCLは片方だけ配線する
GEOFENCE_STAT
S2A
差動USBのダンピング抵抗はデータシートには無かった DTRはプッシュプル出力だが、4.7kでプルダウンすると USBコンフィギュレーションを外部から設定することができる
SEL0

Board: 4 copper layers, 38.5 x 60.0 mm, 65 parts (4 on the bottom side), 58 nets.

File Hardware/CLAS_Combo_Breakout_MovingBase-HAT/BOM.csv:

Source:,D:\GitHub\Low-cost-QZSS-CLAS-module\Hardware\CLAS_Combo_Breakout_MovingBase-HAT\CLAS_Combo_Breakout_MovingBase-HAT.kicad_sch,,,,,
Date:,"2024/04/12 15:18:47",,,,,
Tool:,"Eeschema (6.0.9)",,,,,
Generator:,D:\KiCad\6.0\bin\scripting\plugins/bom_csv_grouped_by_value_with_fp.py,,,,,
"Component Count:",65,,,,,
Ref,Qnty,Value,"Cmp name",Footprint,Description,Vendor,,,,,
"C1, C2, C3, C5, C6, C8, C13, ",7,0.1u,C_Small,Capacitor_SMD:C_0603_1608Metric,"Unpolarized capacitor, small symbol",,,,,,
"C4, ",1,1u,C_Small,Capacitor_SMD:C_0603_1608Metric,"Unpolarized capacitor, small symbol",,,,,,
"C7, C9, ",2,"47μF6.3V X5R 1608",C_Small,Capacitor_SMD:C_0603_1608Metric,"Unpolarized capacitor, small symbol",,,,,,
"C10, ",1,"100μF10V X5R 3216",C_Small,Capacitor_SMD:C_1206_3216Metric,"Unpolarized capacitor, small symbol",,,,,,
"C11, ",1,"2200pF50V CH 1608",C_Small,Capacitor_SMD:C_0603_1608Metric,"Unpolarized capacitor, small symbol",,,,,,
"C12, ",1,"220μF4V X6S 3216",C_Small,Capacitor_SMD:C_1206_3216Metric,"Unpolarized capacitor, small symbol",,,,,,
"D1, D7, ",2,CUHS20S30,D_Schottky_Small,CUHS20S30:CUHS20S30,"Schottky diode, small symbol",,,,,,
"D2, ",1,RED,LED_Small,LED_SMD:LED_0603_1608Metric,"Light emitting diode, small symbol",,,,,,
"D3, ",1,GREEN,LED_Small,LED_SMD:LED_0603_1608Metric,"Light emitting diode, small symbol",,,,,,
"D4, ",1,RTK,LED_Small,LED_SMD:LED_0603_1608Metric,"Light emitting diode, small symbol",,,,,,
"D5, ",1,GEO,LED_Small,LED_SMD:LED_0603_1608Metric,"Light emitting diode, small symbol",,,,,,
"D6, ",1,PPS,LED_Small,LED_SMD:LED_0603_1608Metric,"Light emitting diode, small symbol",,,,,,
"H1, H2, H3, ",3,MH,MountingHole_Pad,MountingHole:MountingHole_2.2mm_M2_Pad_Via,"Mounting Hole with connection",,,,,,
"J1, ",1,MMCX,Conn_Coaxial,Connector_Coaxial_extlib:MMCX_Samtec_MMCX-P-P-H-ST-SM1_Male,"coaxial connector (BNC, SMA, SMB, SMC, Cinch/RCA, LEMO, ...)",,,,,,
"J2, ",1,SMA,Conn_Coaxial,Connector_Coaxial_extlib:SMA_Molex_0732512440_embed,"coaxial connector (BNC, SMA, SMB, SMC, Cinch/RCA, LEMO, ...)",,,,,,
"J3, ",1,SWD,Conn_ARM_JTAG_SWD_10,Connector_PinHeader_1.27mm:PinHeader_2x05_P1.27mm_Vertical,"Cortex Debug Connector, standard ARM Cortex-M SWD and JTAG interface",,,,,,
"J4, ",1,ZED,Conn_01x11,Connector_PinHeader_2.54mm:PinHeader_1x11_P2.54mm_Vertical,"Generic connector, single row, 01x11, script generated (kicad-library-utils/schlib/autogen/connector/)",,,,,,
"J5, ",1,BATT,Conn_01x02,Connector_JST:JST_PH_S2B-PH-K_1x02_P2.00mm_Horizontal,"Generic connector, single row, 01x02, script generated (kicad-library-utils/schlib/autogen/connector/)",,,,,,
"J6, ",1,NEO,Conn_01x07,Connector_PinHeader_2.54mm:PinHeader_1x07_P2.54mm_Vertical,"Generic connector, single row, 01x07, script generated (kicad-library-utils/schlib/autogen/connector/)",,,,,,
"J7, ",1,USB_C_Receptacle_USB2.0,USB_C_Receptacle_USB2.0_1,Connector_USB_extlib:USB_C_Receptacle_5077CR-16-SMC2-BK-TR,"USB 2.0-only Type-C Receptacle connector",,,,,,
"J8, ",1,RS485,Conn_01x03,Connector_JST:JST_PH_S3B-PH-K_1x03_P2.00mm_Horizontal,"Generic connector, single row, 01x03, script generated (kicad-library-utils/schlib/autogen/connector/)",,,,,,
"Q1, ",1,AO3415A,Q_PMOS_GSD,Package_TO_SOT_SMD:SOT-23,"P-MOSFET transistor, gate/source/drain",,,,,,
"R1, R2, ",2,33,R_Small,Resistor_SMD:R_0603_1608Metric,"Resistor, small symbol",,,,,,
"R3, R18, R20, R21, R22, R23, ",6,10k,R_Small,Resistor_SMD:R_0603_1608Metric,"Resistor, small symbol",,,,,,
"R4, ",1,RILIM,R_Small,Resistor_SMD:R_0603_1608Metric,"Resistor, small symbol",,,,,,
"R5, R6, R7, R8, R9, ",5,1k,R_Small,Resistor_SMD:R_0603_1608Metric,"Resistor, small symbol",,,,,,
"R10, ",1,1M,R_Small,Resistor_SMD:R_0603_1608Metric,"Resistor, small symbol",,,,,,
"R11, ",1,510k,R_Small,Resistor_SMD:R_0603_1608Metric,"Resistor, small symbol",,,,,,
"R12, ",1,100k,R_Small,Resistor_SMD:R_0603_1608Metric,"Resistor, small symbol",,,,,,
"R13, ",1,10,R_Small,Resistor_SMD:R_0603_1608Metric,"Resistor, small symbol",,,,,,
"R14, ",1,Rtop,R_Small,Resistor_SMD:R_0603_1608Metric,"Resistor, small symbol",,,,,,
"R15, ",1,Rbtm,R_Small,Resistor_SMD:R_0603_1608Metric,"Resistor, small symbol",,,,,,
"R16, R17, ",2,5.1k,R_Small,Resistor_SMD:R_0603_1608Metric,"Resistor, small symbol",,,,,,
"R19, ",1,26.2k,R_Small,Resistor_SMD:R_0603_1608Metric,"Resistor, small symbol",,,,,,
"R24, ",1,120,R_Small,Resistor_SMD:R_0603_1608Metric,"Resistor, small symbol",,,,,,
"SW1, ",1,SW_Push,SW_Push,Button_Switch_SMD:SW_Push_1P1T_NO_Vertical_Wuerth_434133025816,"Push button switch, generic, two pins",,,,,,
"SW2, ",1,SW_SPDT,SW_SPDT,Button_Switch_SMD_extlib:SW_SPDT_SSSS213202,"Switch, single pole double throw",,,,,,
"U1, ",1,CH340K,CH340K,Package_SO:SSOP-10_3.9x4.9mm_P1.00mm,"USB serial converter, UART, ESSOP-10",,,,,,
"U2, ",1,TMUX131,TMUX131,Package_DFN_QFN_extlib:Texas_RMG0012A_1.8x1.8mm_P0.4mm,,,,,,,
"U3, ",1,ISP4520-AS,ISP4520-AS,RF_Module_extlib:ISP4520-AS_with_Keep-Out,,,,,,,
"U4, ",1,MCP73831-2-OT,MCP73831-2-OT,Package_TO_SOT_SMD:SOT-23-5,"Single cell, Li-Ion/Li-Po charge management controller, 4.20V, Tri-State Status Output, in SOT23-5 package",,,,,,
"U5, ",1,LTM4693,LTM4693,Converter_DCDC_extlib:Converter_DCDC_AnalogDevices_LTM4693,,,,,,,
"U6, ",1,USBLC6-2P6,USBLC6-2P6,Package_TO_SOT_SMD:SOT-666,"Very low capacitance ESD protection diode, 2 data-line, SOT-666",,,,,,
"U7, ",1,MAX3485,MAX3485,Package_SO:SOIC-8_3.9x4.9mm_P1.27mm,"True RS-485/RS-422, 10Mbps, Slew-Rate Limited, with low-power shutdown, with receiver/driver enable, 32 receiver drive capacitity, DIP-8 and SOIC-8",,,,,,
,,,,,,

## KiCad design Hardware/CLAS_Combo_Breakout/CLAS_Combo_Breakout.kicad_pcb

Parts:
ANT1: GGBLA.125.A; Manufacturer_Part_Number GGBLA.125.A; Mouser Part Number 960-GGBLA.125.A
BT1: MS421R
C1, C5, C6, C7, C8, C10: 1u; C_0603_1608Metric
C2, C3, C4, C15: 0.1u; C_0603_1608Metric
C9: DNF; C_0402_1005Metric
C11, C14: 47p; C_0402_1005Metric
C12: 1000p; C_0603_1608Metric
C13: 3.9p; C_0402_1005Metric
C16: 1.2p; C_0402_1005Metric
D1, D2, D7: CUHS20S30
D3: EXTANT; LED_0603_1608Metric
D4: RTK; LED_0603_1608Metric
D5: GEO; LED_0603_1608Metric
D6: PPS; LED_0603_1608Metric
D8: BAS19; SOT-23
D9: BAT54W; SOT-23
D10: PESD0402-140; D_0402_1005Metric
H1, H2, H3, H4: MH; MountingHole_2.2mm_M2_Pad_Via
J1, J4: USB_C_Receptacle_USB2.0; USB_C_Receptacle_5077CR-16-SMC2-BK-TR
J2: ZED; PinHeader_1x11_P2.54mm_Vertical
J3: NEO; PinHeader_1x09_P2.54mm_Vertical
J5: Conn_Coaxial; 0734152063
JP1: I2C; SolderJumper-3_Open_RoundedPad
L1: LQW18ANR12G8ZD
L2: LQW15AN9N5G00D
Q1: DSS20200; SOT-23; Manufacturer_Part_Number DSS20200L-7; Mouser Part Number 621-DSS20200L-7
R1, R2, R3, R4, R5, R6, R7, R11, R12: 33; R_0603_1608Metric
R8, R9: 2.2k; R_0603_1608Metric
R10, R13, R14, R16: 27; R_0603_1608Metric
R15, R17, R18, R19: 5.1k; R_0603_1608Metric
R20, R21, R22, R23: 1k; R_0603_1608Metric
R24: 68; R_0402_1005Metric
R25: 3; R_0603_1608Metric
R26: 22k; R_0402_1005Metric
R27: 3.3k; R_0603_1608Metric
R28: 1.5k; R_0402_1005Metric
R29, R30: 100; R_0402_1005Metric
R31, R33, R34: 0; R_0402_1005Metric
R32: DNF; R_0402_1005Metric
TP1: SAFEBOOT_ZED; TestPoint_Pad_D1.0mm
TP2: SAFEBOOT_NEO; TestPoint_Pad_D1.0mm
U1, U4: USBLC6-2P6; SOT-666
U2: ZED-F9P; ublox_ZED
U3: NEO-D9C-00B; NEO-D9
U5: NJU77251F; SOT-23-5
U6: AP2112K-3.3; SOT-23-5
U7: NT1191GEAE3S
U8: F2933NBGP; Manufacturer_Part_Number F2933NBGP; Mouser Part Number 972-F2933NBGP
U9: PD0922J5050S2HF; PD0922J5050S2HF_ANA

Connections:
+3.3V: C1.1, C2.1, C4.1, C5.2, C6.2, C8.1, C10.1, C12.1, C15.1, D7.2 (A), J2.9, J3.7, JP1.2 (C), R21.1, R32.1, U2.33 (VCC), U2.34 (VCC), U2.38 (V_USB), U3.7 (V_USB), U3.23 (VCC), U5.5 (V+), U6.5 (VOUT), U7.1 (VCTL), U7.5 (VDD), U8.1 (VDD)
+3.3V_RF: D8.1 (A), R24.1, R25.2, U3.9 (VCC_RF)
+5V: C7.1, D1.1 (K), D2.1 (K), U6.1 (VIN), U6.3 (EN)
/ANT_NEO: R29.2, U3.11 (RF_IN), U9.6 (OUT2)
/ANT_ZED: R29.1, U2.2 (RF_IN), U9.4 (OUT1)
/CC1_NEO: J4.A5 (CC1), R17.1
/CC1_ZED: J1.A5 (CC1), R19.1
/CC2_NEO: J4.B5 (CC2), R15.1
/CC2_ZED: J1.B5 (CC2), R18.1
/D+NEO: J4.A6 (D+), J4.B6 (D+), R14.2, U4.4 (I/O2)
/D+ZED: J1.A6 (D+), J1.B6 (D+), R10.1, U1.6 (I/O1)
/D-NEO: J4.A7 (D-), J4.B7 (D-), R16.2, U4.6 (I/O1)
/D-ZED: J1.A7 (D-), J1.B7 (D-), R13.1, U1.4 (I/O2)
/EXTANT_DETECT: J3.1, R20.1, R30.2, R32.2, U5.4
/EXTINT_NEO: J3.5, U3.17 (EXTINT)
/EXTINT_ZED: J2.4, U2.51 (EXTINT)
/GEO: J2.1, R22.1, U2.19 (GEOFENCE_STAT)
/RESET: J3.2, U2.49 (~RESET), U3.8 (~RESET)
/RTK: D4.1 (K), J2.2, U2.20 (RTK_STAT)
/RXD1_NEO: J3.3, U3.21 (RXD1/SPI_MOSI)
/RXD1_ZED: J2.6, U2.43 (RXD/SPI_MOSI)
/SCL: J2.11, J3.9, R2.1, R3.2, R8.2
/SCL_NEO_: R2.2, U3.19 (SCL/SPI_SLK)
/SCL_ZED_: R3.1, U2.45 (SCL/SPI_CLK)
/SDA: J2.10, J3.8, R4.2, R5.1, R9.2
/SDA_NEO_: R5.2, U3.18 (SDA/~SPI_CS)
/SDA_ZED_: R4.1, U2.44 (SDA/~SPI_CS)
/TP: J2.3, R23.1, U2.53 (TIMEPULSE)
/TXD1_NEO: J3.4, R7.1
/TXD1_NEO_: R7.2, U3.20 (TXD1/SPI_MISO)
/TXD1_ZED: J2.7, R6.2
/TXD1_ZED_: R6.1, U2.42 (TXD/SPI_MISO)
/TX_RDY: J2.5, R1.2
/TX_RDY_: R1.1, U2.46 (TX_READY)
/VBUS_NEO: D2.2 (A), J4.A4 (VBUS), J4.A9 (VBUS), J4.B4 (VBUS), J4.B9 (VBUS), U4.5 (VBUS)
/VBUS_ZED: D1.2 (A), J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), U1.5 (VBUS)
/V_BACKUP: BT1.1 (+), R27.2, U2.36 (V_BCKP)
GND: BT1.2 (-), C1.2, C2.2, C3.1, C4.2, C5.1, C6.1, C7.2, C8.2, C9.2, C10.2, C12.2, C15.2, C16.2, D3.1 (K), D5.1 (K), D6.1 (K), D10.1 (A1), H1.1, H2.1, H3.1, H4.1, J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.S1 (SHIELD), J2.8, J3.6, J4.A1 (GND), J4.A12 (GND), J4.B1 (GND), J4.B12 (GND), J4.S1 (SHIELD), J5.2 (Ext), R15.2, R17.2, R18.2, R19.2, R26.2, R28.1, R33.2, R34.2, U1.2 (GND), U2.1 (GND), U2.3 (GND), U2.12 (GND), U2.14 (GND), U2.32 (GND), U2.37 (GND), U2.41 (GND), U2.48 (GND), U2.55 (GND), U3.10 (GND), U3.12 (GND), U3.13 (GND), U3.24 (GND), U4.2 (GND), U5.2 (V-), U6.2 (GND), U7.3 (GND), U7.6 (NC(GND)), U7.7 (EP), U8.4 (GND), U8.5 (GND), U8.6 (GND), U8.7 (GND), U8.8 (GND), U8.10 (GND), U8.11 (GND), U8.13 (GND), U8.14 (GND), U8.15 (GND), U8.17 (EP), U9.1 (GND), U9.3 (GND), U9.5 (GND)
unnamed: ANT1.1 (RF_FEED(50Ω)), C13.1, C16.1
unnamed: ANT1.2 (GND), R33.1
unnamed: ANT1.3 (GND), R34.1
unnamed: C3.2, L1.1, Q1.3 (C)
unnamed: C11.1, D10.2 (A2), J5.1 (In), L1.2
unnamed: C11.2, U8.9 (RF2)
unnamed: C9.1, C13.2, R31.1
unnamed: C14.1, U8.12 (RF1)
unnamed: C14.2, U7.4 (RFOUT)
unnamed: D3.2 (A), R20.2
unnamed: D4.2 (A), R21.2
unnamed: D5.2 (A), R22.2
unnamed: D6.2 (A), R23.2
unnamed: D7.1 (K), R27.1
unnamed: D8.3 (K), D9.1 (A)
unnamed: D9.3 (K), Q1.1 (B), R28.2
unnamed: JP1.1 (A), R9.1
unnamed: JP1.3 (B), R8.1
unnamed: L2.1, R31.2
unnamed: L2.2, U7.2 (RFIN)
unnamed: Q1.2 (E), R25.1, U5.3 (-)
unnamed: R10.2, U2.40 (USB_D+)
unnamed: R11.1, U2.27 (TXD2)
unnamed: R11.2, U3.4 (RXD2)
unnamed: R12.1, U2.26 (RXD2)
unnamed: R12.2, U3.3 (TXD2)
unnamed: R13.2, U2.39 (USB_D-)
unnamed: R14.1, U3.6 (USB_D+)
unnamed: R16.1, U3.5 (USB_D-)
unnamed: R24.2, R26.1, U5.1 (+)
unnamed: R30.1, U8.2 (VCTL)
unnamed: TP1.1, U2.50 (~SAFEBOOT)
unnamed: TP2.1, U3.1 (~SAFEBOOT)
unnamed: U8.3 (RFC), U9.2 (IN)

Notes on the sheet:
USB
detection current:3mA
RF Amplifiers
Interface
RTK_STAT
Indicator
Initial Charge: 3.0-3.3V Charge Rate: 1mA MAX Voff: 2.0V
TIMEPULSE
9.5nH
Backup Battery
Auto antenna select
RF Receiver
3.29V
Push-Pull Output
GEOFENCE_STAT
ZED-F9P_NEO-D9C_Combo
Omit damping resistor
アンテナが接続されていないとLOW 接続されるとHI
Close Jumper to add I2C pullup
External active antenna detect
Voltage Regulation
PullUp

Board: 4 copper layers, 60.0 x 60.0 mm, 86 parts (0 on the bottom side), 72 nets.

File Hardware/CLAS_Combo_Breakout/BOM.csv:

Ref,Qnty,digikey,Check,Value,"Cmp name",Footprint,Description
"ANT1,",1,https://www.digikey.jp/ja/products/detail/taoglas-limited/GG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,in18,GGBLA.125.A,GGBLA.125.A,GGBLA.125.A:GGBLA.125.A,"Antennas GPS/GLONASS/GALILEO BeiDou Ceramic"
"BT1,",1,https://www.chip1stop.com/view/dispDetail/DispDetail?partId=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,done,MS421R,Battery_Cell,Battery_extlib:MS421R,"Single-cell battery"
"C1, C3, C5, C6, C7, C8,",6,ストック,,1u,C_Small,Capacitor_SMD:C_0603_1608Metric,"Unpolarized capacitor, small symbol"
"C2, C4, C15,",3,ストック,,0.1u,C_Small,Capacitor_SMD:C_0603_1608Metric,"Unpolarized capacitor, small symbol"
"C9,",1,ダミー,,DNF,C_Small,Capacitor_SMD:C_0402_1005Metric,"Unpolarized capacitor, small symbol",,,,,
"C10,",1,ストック,,0.1u,C_Small,Capacitor_SMD:C_0402_1005Metric,"Unpolarized capacitor, small symbol",,,,,
"C11, C14,",2,https://www.digikey.jp/ja/products/detail/murata-electronics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,in11,47p,C_Small,Capacitor_SMD:C_0402_1005Metric,"Unpolarized capacitor, small symbol",,,,,
"C12,",1,ストック,,1000p,C_Small,Capacitor_SMD:C_0603_1608Metric,"Unpolarized capacitor, small symbol",,,,,
"C13,",1,https://www.digikey.jp/ja/products/detail/murata-electronics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,in10,3.9p,C_Small,Capacitor_SMD:C_0402_1005Metric,"Unpolarized capacitor, small symbol",,,,,
"C16,",1,https://www.digikey.jp/ja/products/detail/murata-electronics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,in9,1.2p,C_Small,Capacitor_SMD:C_0402_1005Metric,"Unpolarized capacitor, small symbol",,,,,
"D1, D2, D7,",3,ストック,,CUHS20S30,D_Schottky_Small,CUHS20S30:CUHS20S30,"Schottky diode, small symbol",,,,,
"D3,",1,ストック,,EXTANT,LED_Small,LED_SMD:LED_0603_1608Metric,"Light emitting diode, small symbol",,,,,
"D4,",1,ストック,,RTK,LED_Small,LED_SMD:LED_0603_1608Metric,"Light emitting diode, small symbol",,,,,
"D5,",1,ストック,,GEO,LED_Small,LED_SMD:LED_0603_1608Metric,"Light emitting diode, small symbol",,,,,
"D6,",1,ストック,,PPS,LED_Small,LED_SMD:LED_0603_1608Metric,"Light emitting diode, small symbol",,,,,
"D8,",1,https://www.digikey.jp/ja/products/detail/diodes-incorporate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,in2,BAS19,BAS19,Package_TO_SOT_SMD:SOT-23,"120V, 0.4A, High-speed Switching Diode, SOT-23",,,,,
"D9,",1,https://www.digikey.jp/ja/products/detail/diodes-incorporate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,in3,BAT54W,BAT54W,Package_TO_SOT_SMD:SOT-23,"Schottky barrier diode, SOT-323",,,,,
"D10,",1,https://www.digikey.jp/ja/products/detail/littelfuse-inc/PES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,in7,PESD0402-140,D_TVS,Diode_SMD:D_0402_1005Metric,"Bidirectional transient-voltage-suppression diode",,,,,
"H1, H2, H3, H4,",4,ダミー,,MH,MountingHole_Pad,MountingHole:MountingHole_2.2mm_M2_Pad_Via,"Mounting Hole with connection",,,,,
"J1, J4,",2,ストック,,USB_C_Receptacle_USB2.0,USB_C_Receptacle_USB2.0,Connector_USB_extlib:USB_C_Receptacle_5077CR-16-SMC2-BK-TR,"USB 2.0-only Type-C Receptacle connector",,,,,
"J2,",1,ストック,,ZED,Conn_01x11,Connector_PinHeader_2.54mm:PinHeader_1x11_P2.54mm_Vertical,"Generic connector, single row, 01x11, script generated (kicad-library-utils/schlib/autogen/connector/)",,,,,
"J3,",1,ストック,,NEO,Conn_01x09,Connector_PinHeader_2.54mm:PinHeader_1x09_P2.54mm_Vertical,"Generic connector, single row, 01x09, script generated (kicad-library-utils/schlib/autogen/connector/)",,,,,
"J5,",1,https://www.digikey.jp/ja/products/detail/molex/0734152063/2421475,in8,Conn_Coaxial,Conn_Coaxial,Connector_Coaxial_extlib:0734152063,"coaxial connector (BNC, SMA, SMB, SMC, Cinch/RCA, LEMO, ...)",,,,,
"JP1,",1,ダミー,,I2C,SolderJumper_3_Open,Jumper_extlib:SolderJumper-3_Open_RoundedPad,"Solder Jumper, 3-pole, open",,,,,
"L1,",1,https://www.digikey.jp/ja/products/detail/murata-electronics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,in13,LQW18ANR12G8ZD,L_Small,LQW18ANR12G8ZD:LQW18ANR12G8ZD,"Inductor, small symbol",,,,,
"L2,",1,https://www.digikey.jp/ja/products/detail/murata-electronics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,in12,LQW15AN9N5G00D,L_Small,LQW15AN9N5G00D:LQW15AN9N5G00D,"Inductor, small symbol",,,,,
"Q1,",1,https://www.digikey.jp/ja/products/detail/diodes-incorporate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,in4,DSS20200,DSS20200L-7,DSS20200L-7:DSS20200L-7,"Diodes Inc DSS20200L-7 PNP Bipolar Transistor, -2 A, -20 V, 3-Pin SOT-23",,,,,
"R1, R2, R3, R4, R5, R6, R7, R11, R12,",9,ストック,,33,R_Small,Resistor_SMD:R_0603_1608Metric,"Resistor, small symbol",,,,,
"R8, R9,",2,ストック,,2.2k,R_Small,Resistor_SMD:R_0603_1608Metric,"Resistor, small symbol",,,,,
"R10, R13, R14, R16,",4,ストック,,27,R_Small,Resistor_SMD:R_0603_1608Metric,"Resistor, small symbol",,,,,
"R15, R17, R18, R19,",4,ストック,,5.1k,R_Small,Resistor_SMD:R_0603_1608Metric,"Resistor, small symbol",,,,,
"R20, R21, R22, R23,",4,ストック,,1k,R_Small,Resistor_SMD:R_0603_1608Metric,"Resistor, small symbol",,,,,
"R24,",1,ストック(アンテナ電源用),,68,R_Small,Resistor_SMD:R_0603_1608Metric,"Resistor, small symbol",,,,,
"R25,",1,ストック(アンテナ電源用),,3,R_Small,Resistor_SMD:R_0603_1608Metric,"Resistor, small symbol",,,,,
"R26,",1,ストック(アンテナ電源用),,22k,R_Small,Resistor_SMD:R_0603_1608Metric,"Resistor, small symbol",,,,,
"R27,",1,ストック,,3.3k,R_Small,Resistor_SMD:R_0603_1608Metric,"Resistor, small symbol",,,,,
"R28,",1,ストック(アンテナ電源用),,1.5k,R_Small,Resistor_SMD:R_0603_1608Metric,"Resistor, small symbol",,,,,
"R29, R30,",2,https://www.digikey.jp/ja/products/detail/vishay-dale-thin-f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,in21,100,R_Small,Resistor_SMD:R_0603_1608Metric,"Resistor, small symbol",,,,,
"R31, R33, R34,",3,"https://www.digikey.jp/ja/products/detail/koa-speer-electron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,https://www.digikey.jp/ja/products/detail/yageo/RC0402JR-070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","in5,in6",0,R_Small,Resistor_SMD:R_0402_1005Metric,"Resistor, small symbol",,,,,
"R32,",1,ストック,,10k,R_Small,Resistor_SMD:R_0603_1608Metric,"Resistor, small symbol",,,,,
"TP1,",1,ダミー,,SAFEBOOT_ZED,TestPoint,TestPoint:TestPoint_Pad_D1.0mm,"test point",,,,,
"TP2,",1,ダミー,,SAFEBOOT_NEO,TestPoint,TestPoint:TestPoint_Pad_D1.0mm,"test point",,,,,
"U1, U4,",2,https://www.digikey.jp/ja/products/detail/stmicroelectronics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,in16,USBLC6-2P6,USBLC6-2P6,Package_TO_SOT_SMD:SOT-666,"Very low capacitance ESD protection diode, 2 data-line, SOT-666",,,,,
"U2,",1,https://www.digikey.jp/ja/products/detail/u-blox/ZED-F9P-04B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,mouserで別途買う,ZED-F9P,ZED-F9P,RF_GPS:ublox_ZED,"GNSS Module ZED F9, VCC 2.7V to 3.6V, LGA-54",,,,,
"U3,",1,https://www.digikey.jp/ja/products/detail/u-blox/NEO-D9C-00B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,in20,NEO-D9C-00B,NEO-D9C-00B,NEO-D9:NEO-D9,,,,,,
"U5,",1,https://www.digikey.jp/ja/products/detail/texas-instruments/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,in19,LMV331,LMV331,Package_TO_SOT_SMD:SOT-23-5,"Single General-Purpose Low-Voltage Comparator, SOT-23-5/SC-70-5",,,,,
"U6,",1,https://www.digikey.jp/ja/products/detail/diodes-incorporate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,in1,AP2112K-3.3,AP2112K-3.3,Package_TO_SOT_SMD:SOT-23-5,"600mA low dropout linear regulator, with enable pin, 3.8V-6V input voltage range, 3.3V fixed positive output, SOT-23-5",,,,,
"U7,",1,https://www.digikey.jp/ja/products/detail/nisshinbo-micro-de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,in14,NT1191GEAE3S,NT1191GEAE3S,NT1191GEAE3S:NT1191GEAE3S,,,,,,
"U8,",1,https://www.digikey.jp/ja/products/detail/renesas-electronic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,in15,F2933NBGP,F2933NBGP,F2933NBGP:F2933NBGP,"The F2933is a high-reliability, low-insertion loss, 50  SP2T absorptive RF switch designed for a wide range of markets and applications.",,,,,
"U9,",1,https://www.digikey.jp/ja/products/detail/ttm-technologies-i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,mouserで別途買う,PD0922J5050S2HF,PD0922J5050S2HF,PD0922J5050S2HF:PD0922J5050S2HF_ANA,,,,,,
other,1,https://www.digikey.jp/ja/products/detail/taoglas-limited/CA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,in17,"MMCX to SMA",,,,,,,,
